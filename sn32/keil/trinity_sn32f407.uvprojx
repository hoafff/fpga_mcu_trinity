# Keil uVision project trinity_sn32f407.uvprojx, settings and files
target trinity_sn32f407 (6240000::V6.24::ARMCLANG)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x7FFC) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: trinity_sn32f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: TRINITY_S0_EXACT_TARGET=1
  c include: ..\config
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Trinity Application
    ../src/app/: trinity_main.c
    ../config/: trinity_build_config.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.1
